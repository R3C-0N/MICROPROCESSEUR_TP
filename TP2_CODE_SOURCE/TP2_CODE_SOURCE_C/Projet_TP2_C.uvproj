# Keil uVision project Projet_TP2_C.uvproj, settings and files
target Simulation (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: Projet_TP2_C
  c flags: Optimize=8 SizeSpeed=1
  group Programmes Source 1
    ./: Main_Test.c STARTUP.A51 Librairie_ASM.asm
target Exécution 8051FX20-TB (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: Projet_TP2_C
  c flags: Optimize=8 SizeSpeed=1
