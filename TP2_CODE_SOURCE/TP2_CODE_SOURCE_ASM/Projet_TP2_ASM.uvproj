# Keil uVision project Projet_TP2_ASM.uvproj, settings and files
target Simulation (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: Projet_TP2_ASM
  c flags: Optimize=8 SizeSpeed=1
  group Programmes Source 1
    ./: Base_SM2.asm
target Exécution 8051FX20-TB (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: Projet_TP2_ASM
  c flags: Optimize=8 SizeSpeed=1
