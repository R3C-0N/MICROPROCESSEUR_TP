# Keil uVision project Essai_Uvision4.uvproj, settings and files
target Simulation (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: Essai_Uvision3
  c flags: Optimize=8 SizeSpeed=1
  group New Group
    ./: Demo_TP_SM1.asm EXO_SM1.asm
target Exécution 8051FX20-TB (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: Essai
  c flags: Optimize=8 SizeSpeed=1
